# Keil uVision project P01_LED_UART2.uvprojx, settings and files
target TLE9879_EvalKit (6190000::V6.19::ARMCLANG)
  device: TLE9879QXA40 Infineon
  pack: Infineon.TLE987x_DFP.1.6.0
  cpu: IRAM(0x18000018,0x17E8) IRAM2(0x18000000,0x10) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UART2_TTY
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x1effc
  memory RVCT5: ROM 0x1101effc size 0x1004
  memory RVCT9: RAM 0x18000018 size 0x17e8
  memory RVCT10: RAM 0x18000000 size 0x10
  group App
    ./app/: main.c
software components: CMSIS:CORE 5.6.0, Device:ConfigWizard_v2 2.1.12, Device:SDK:ADC1 0.3.0, Device:SDK:ADC2 0.2.6, Device:SDK:BOOTROM 0.3.3, Device:SDK:CCU6 0.4.1, Device:SDK:INT 0.2.3, Device:SDK:ISR 0.2.9, Device:SDK:LIN 0.2.0, Device:SDK:PMU 0.2.2, Device:SDK:PORT 0.6.0, Device:SDK:SCU 0.5.7, Device:SDK:UART 0.2.4, Device:SDK:WDT1 0.3.3, Device:Startup 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
